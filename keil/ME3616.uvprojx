# Keil uVision project ME3616.uvprojx, settings and files
target UART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ME3616Uart +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\Libs;..\Libs\inc;..\user\delay;..\user\usart;..\user\sys
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../user/usart/: usart.c
    ../user/sys/: sys.c
    ../user/delay/: delay.c
  group FWLib
    ../Libs/src/: misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
    ../Libs/: core_cm3.c startup_stm32f10x_md.s
software components: CMSIS:CORE 5.1.1
